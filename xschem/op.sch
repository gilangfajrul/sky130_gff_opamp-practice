v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 80 -210 2 0 {name=p1 lab=vdd}
C {devices/iopin.sym} 80 -130 2 0 {name=p2 lab=gnd}
C {devices/ipin.sym} 80 -90 0 0 {name=p3 lab=vip}
C {devices/ipin.sym} 80 -50 0 0 {name=p4 lab=vin}
C {devices/opin.sym} 60 -170 0 0 {name=p5 lab=out}
